# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=188,546,68,111
  c include: .\Start;.\Library;.\User;.\System;.\Hardware;.\LVGL;.\LVGL\src;.\LVGL\porting
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: LED.c LED.h Key.c Key.h OLED.c OLED.h OLED_Font.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group LVGL_conf
    ./LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ./LVGL/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ./LVGL/src/: lv_init.c
    ./LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ./LVGL/src/display/: lv_display.c
    ./LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_buf.c lv_image_decoder.c
    ./LVGL/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ./LVGL/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_draw_vglite_triangle.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ./LVGL/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ./LVGL/src/draw/sdl/: lv_draw_sdl.c
    ./LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ./LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c
    ./LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_decoder.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_utils.c
    ./LVGL/src/drivers/display/drm/: lv_linux_drm.c
    ./LVGL/src/drivers/display/fb/: lv_linux_fbdev.c
    ./LVGL/src/drivers/display/ili9341/: lv_ili9341.c
    ./LVGL/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ./LVGL/src/drivers/display/st7735/: lv_st7735.c
    ./LVGL/src/drivers/display/st7789/: lv_st7789.c
    ./LVGL/src/drivers/display/st7796/: lv_st7796.c
    ./LVGL/src/drivers/evdev/: lv_evdev.c
    ./LVGL/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ./LVGL/src/drivers/sdl/: lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_window.c
    ./LVGL/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ./LVGL/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ./LVGL/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./LVGL/src/indev/: lv_indev.c lv_indev_scroll.c
    ./LVGL/src/layouts/: lv_layout.c
    ./LVGL/src/layouts/flex/: lv_flex.c
    ./LVGL/src/layouts/grid/: lv_grid.c
    ./LVGL/src/libs/barcode/: code128.c lv_barcode.c
    ./LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ./LVGL/src/libs/bmp/: lv_bmp.c
    ./LVGL/src/libs/ffmpeg/: lv_ffmpeg.c
    ./LVGL/src/libs/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ./LVGL/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./LVGL/src/libs/gif/: gifdec.c lv_gif.c
    ./LVGL/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ./LVGL/src/libs/libpng/: lv_libpng.c
    ./LVGL/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ./LVGL/src/libs/lz4/: lz4.c
    ./LVGL/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./LVGL/src/libs/rle/: lv_rle.c
    ./LVGL/src/libs/rlottie/: lv_rlottie.c
    ./LVGL/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ./LVGL/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ./LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
    ./LVGL/src/misc/cache/: _lv_cache_lru_rb.c lv_cache.c lv_cache_entry.c lv_image_cache.c
    ./LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
    ./LVGL/src/others/file_explorer/: lv_file_explorer.c
    ./LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./LVGL/src/others/gridnav/: lv_gridnav.c
    ./LVGL/src/others/ime/: lv_ime_pinyin.c
    ./LVGL/src/others/imgfont/: lv_imgfont.c
    ./LVGL/src/others/monkey/: lv_monkey.c
    ./LVGL/src/others/observer/: lv_observer.c
    ./LVGL/src/others/snapshot/: lv_snapshot.c
    ./LVGL/src/others/sysmon/: lv_sysmon.c
    ./LVGL/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ./LVGL/src/stdlib/: lv_mem.c
    ./LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ./LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ./LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ./LVGL/src/themes/: lv_theme.c
    ./LVGL/src/themes/default/: lv_theme_default.c
    ./LVGL/src/themes/mono/: lv_theme_mono.c
    ./LVGL/src/themes/simple/: lv_theme_simple.c
    ./LVGL/src/tick/: lv_tick.c
    ./LVGL/src/widgets/animimage/: lv_animimage.c
    ./LVGL/src/widgets/arc/: lv_arc.c
    ./LVGL/src/widgets/bar/: lv_bar.c
    ./LVGL/src/widgets/button/: lv_button.c
    ./LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ./LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/src/widgets/canvas/: lv_canvas.c
    ./LVGL/src/widgets/chart/: lv_chart.c
    ./LVGL/src/widgets/checkbox/: lv_checkbox.c
    ./LVGL/src/widgets/dropdown/: lv_dropdown.c
    ./LVGL/src/widgets/image/: lv_image.c
    ./LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ./LVGL/src/widgets/keyboard/: lv_keyboard.c
    ./LVGL/src/widgets/label/: lv_label.c
    ./LVGL/src/widgets/led/: lv_led.c
    ./LVGL/src/widgets/line/: lv_line.c
    ./LVGL/src/widgets/list/: lv_list.c
    ./LVGL/src/widgets/menu/: lv_menu.c
    ./LVGL/src/widgets/msgbox/: lv_msgbox.c
    ./LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ./LVGL/src/widgets/roller/: lv_roller.c
    ./LVGL/src/widgets/scale/: lv_scale.c
    ./LVGL/src/widgets/slider/: lv_slider.c
    ./LVGL/src/widgets/span/: lv_span.c
    ./LVGL/src/widgets/spinbox/: lv_spinbox.c
    ./LVGL/src/widgets/spinner/: lv_spinner.c
    ./LVGL/src/widgets/switch/: lv_switch.c
    ./LVGL/src/widgets/table/: lv_table.c
    ./LVGL/src/widgets/tabview/: lv_tabview.c
    ./LVGL/src/widgets/textarea/: lv_textarea.c
    ./LVGL/src/widgets/tileview/: lv_tileview.c
    ./LVGL/src/widgets/win/: lv_win.c
